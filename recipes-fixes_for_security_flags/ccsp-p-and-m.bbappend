FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://rockwell_security_fix_ccsp-p-and-m.patch"
