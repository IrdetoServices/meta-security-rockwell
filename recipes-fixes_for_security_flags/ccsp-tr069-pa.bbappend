FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://rockwell_security_fix_ccsp-tr069-pa.patch"
