FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://rockwell_security_fix_test-and-diagnostic.patch"
